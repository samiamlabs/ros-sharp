Commit message: Multiple truck with rocon

File: Unity3D/Assets/Urdf/default/robot_description.urdf (robot description, URDF)
Before this commit: robot dyno_forklift, 10 links, 9 joints
Joints:
- joint fork_joint: origin xyz=0.106 0 0 rpy=0 0 0 -> xyz=0.106 0 -0.013 rpy=0 0 0
